## kernel/drivers/char/sampledriver/Kconfig
```kconfig
config TEST_CODE
	tristate "TEST_CODE"
	default y
	help
	compile for TEST CODE,y for kernel,m for module.
```
